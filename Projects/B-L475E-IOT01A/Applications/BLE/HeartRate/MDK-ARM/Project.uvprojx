# Keil uVision project Project.uvprojx, settings and files
target STM32L4_IOT_HR (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L4_IOT_HR
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_STM32L475_IOT_DISCO,USE_HAL_DRIVER,SET_L2CAP_CONN_UPD_REQ_COMMAND,ENABLE_SPI_FIX,BLUENRG_MS
  c misc: --C99
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../Common/ble_core/;../../Common/ble_services/;../../Common/debug/;../../Common/hw/;../../Common/tl/;../../Common/utilities/;../../Common/;../Inc/
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/Common/ble_services
    ../../Common/ble_services/: svc_ctl.c dis.c hrs.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ./: startup_stm32l475xx.s
  group Application/Common/utilities
    ../../Common/utilities/: scheduler.c memory_manager.c list.c lpm.c
  group Application/Common/tl
    ../../Common/tl/: tl_ble_hci.c tl_ble_spi.c tl_ble_reassembly.c tl_ble_io.c
  group Drivers/STM32L4xx_HAL_Drivers
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rcc_ex.c stm32l4xx_hal.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_rtc.c
  group Application/Common/ble_core
    ../../Common/ble_core/: bluenrg_gatt_aci.c bluenrg_hal_aci.c osal.c bluenrg_gap_aci.c
  group Application/HR_Example
    ../Src/: stm32l4xx_it.c main.c dis_app.c hr.c hrs_app.c system_stm32l4xx.c
  group Application/Common/hw_interface
    ../../Common/hw/: hw_spi.c hw_lpm.c hw_timerserver.c
software components: CMSIS:CORE 4.3.0

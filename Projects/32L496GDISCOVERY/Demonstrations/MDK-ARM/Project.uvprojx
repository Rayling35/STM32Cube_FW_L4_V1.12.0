# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496G-Discovery +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx,USE_FULL_ASSERT,USE_FULL_LL_DRIVER,DIM_FEATURE_ENABLED,INIT_BLACK_LCD
  c misc: --C99
  c include: ../STemWin_Addons;../Core/inc;../Config;../Modules/audio_player;../Modules/audio_recorder;../Modules/iddmeasure;../Modules/usb_storage;../Modules/main_app;../Modules/common;../Modules/videoplayer;../../../../Utilities/CPU;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L496G-Discovery;../../../../Drivers/BSP/Components;../../../../Drivers/BSP/Components/ft6x06;../../../../Drivers/BSP/Components/st7789h2;../../../../Drivers/BSP/Components/mx25r6435f;../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../Middlewares/ST/STemWin/inc;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../Drivers/CMSIS/Include
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: STM32L496G-Discovery\STM32L496G-Discovery.sct
  link misc: --keep=*.o(.TARAFlashSection) --keep=*.o(.TGFXFlashSection) --keep=*.o(.TARAResSection) --keep=*.o(.TGFXResSection)
  group Doc
    ../: readme.txt
  group Middlewares/USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c timers.c queue.c croutine.c tasks.c event_groups.c
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin540_CM4_OS_IAR_ot.a
  group Application/User/Modules/Audio_Player
    ../Modules/audio_player/: audio_player_win.c audio_player_app.c
  group Middlewares/USBD_Library/Config
    ../Config/: usbd_conf.c
  group Application/User/Modules/IDD_Measure
    ../Modules/iddmeasure/: iddmeasure.c iddmeasure_win.c
  group Application/User/Modules/TouchGFX_FULLdemo
    ../Modules/third_party_touchGFX_FULL/: TouchGFX_FULL_win.c
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c
    ../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Middlewares/USBD_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_data.c usbd_msc_bot.c usbd_msc.c usbd_msc_scsi.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Application/User/Modules/Analog_Clock
    ../Modules/analog_clock/: analog_clock_win.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery_io.c stm32l496g_discovery_qspi.c stm32l496g_discovery_sd.c stm32l496g_discovery_idd.c stm32l496g_discovery.c stm32l496g_discovery_audio.c stm32l496g_discovery_ts.c stm32l496g_discovery_lcd.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Application/User/Modules/STemWin_demo
    ../Modules/STemWin_demo/: STemWin_win .c
  group Application/User/Modules/Common
    ../Modules/common/: audio_if.c
  group Middlewares/STemWin/Config
    ../Config/: GUIConf.c LCDConf.c
  group Application/User/Core
    ../Core/Src/: stm32l4xx_it.c stm32l4xx_hal_timebase_tim.c k_bsp.c main.c k_menu.c k_mfx.c k_calibration.c k_sd_diskio.c k_startup.c k_storage.c k_rtc.c k_module.c
  group Application/User/Modules/USB_Storage
    ../Modules/usb_storage/: usbd_desc.c usbd_app.c usb_storage_win.c usbd_storage.c
  group Drivers/CMSIS
    ../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Application/User/Modules/back_STemWin
    ../Modules/back_STemWin/: BackSTemWin_win.c
  group Application/User/Modules/EmbeddedWizard_demo
    ../Modules/third_party_tara/: EmbeddedWizard_bin.c EWIZ_resources.c EmbeddedWizard_win.c
  group Drivers/STM32L4xx_HAL_Drivers
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_sai.c stm32l4xx_hal_rtc.c stm32l4xx_hal_pwr.c stm32l4xx_ll_fmc.c stm32l4xx_ll_dma2d.c stm32l4xx_hal_flash.c stm32l4xx_hal_rcc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_lcd.c stm32l4xx_hal_crc.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_tim.c stm32l4xx_hal.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_spi_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_spi.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_sd.c stm32l4xx_ll_usb.c stm32l4xx_hal_dma.c stm32l4xx_hal_rng.c stm32l4xx_hal_adc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Application/User/Modules/Information
    ../Modules/information/: information_win.c
  group Application/User/Modules/Video_Player
    ../Modules/videoplayer/: video_player_win.c GUI_AVI.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User/Modules/TouchGFX_demo
    ../Modules/third_party_touchGFX/: TGFX_Lite_resources.c TouchGFX_bin.c TouchGFX_win.c
  group Application/User/Modules/Audio_Recorder
    ../Modules/audio_recorder/: audio_recorder_win.c audio_recorder_app.c
  group Middlewares/STemWin/OS
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
software components: CMSIS:CORE 4.3.0

# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496G-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STemWin/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery.c stm32l496g_discovery_ts.c stm32l496g_discovery_io.c stm32l496g_discovery_lcd.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Middlewares/STemWin/Config
    ../Src/: LCDConf_stm32l496g_discovery.c GUIConf_stm32l496g_discovery.c
  group Application/User
    ../Src/: rtc.c calibration.c main.c stm32l4xx_it.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rtc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_ll_fmc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin540_CM4_IAR_ot.a
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Application/Demo
    ../Demo/: GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_Cursor.c GUIDEMO_Resource.c GUIDEMO_Speedometer.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Intro.c GUIDEMO_Automotive.c GUIDEMO_VScreen.c GUIDEMO_ColorBar.c GUIDEMO_Start.c GUIDEMO_Skinning.c GUIDEMO_Graph.c GUIDEMO_Listview.c GUIDEMO_Bitmap.c GUIDEMO_AntialiasedText.c GUIDEMO_Conf.c GUIDEMO.c GUIDEMO_WashingMachine.c GUIDEMO_ImageFlow.c GUIDEMO_BarGraph.c GUIDEMO_Speed.c GUIDEMO_Fading.c GUIDEMO_RadialMenu.c GUIDEMO_IconView.c
software components: CMSIS:CORE 4.3.0
